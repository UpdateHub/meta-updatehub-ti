FILESEXTRAPATHS:prepend := "${THISDIR}/${PN}:"

dirs755:append:updatehub-ti = " /data"
